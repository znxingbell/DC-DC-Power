# Repository znxingbell/DC-DC-Power

## KiCad design dcdc.kicad_pcb

Parts:
C1, C2, C3, C6, C14, C22, C23, C24, C25, C26, C28, C32, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46: 100n; C_0603_1608Metric
C4, C5, C7, C8, C9, C11, C31, C33, C47, C48: 10u; C_1206_3216Metric
C10, C12, C27, C29: 220u; CP_Elec_10x10
C13, C15, C18, C19: 2.2n; C_0603_1608Metric
C16, C17: 47p; C_0603_1608Metric
C20, C21: 33u; CP_EIA-3528-15_AVX-H
C30: 1u; C_0603_1608Metric
D1: SMBJ40A; D_SMB
D2, D3, D14, D15, D16, D17: LED; LED_0603_1608Metric
D4, D5: SMF10A; D_SMF
D6: SMF5V0A; D_SMF
D7: SMF12A; D_SMF
D8, D9, D13: BAV99; SOT-23-3
D10, D11: SS36; D_SMA
D12: SMBJ24A; D_SMB
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Horizontal
L1, L2: 47u; L_APV_APH0630
L3: 68u; L_APV_APH1265
Q1, Q2: IPD025N06N; TO-252-2
R1: 100k; R_0603_1608Metric
R2: 43k; R_0603_1608Metric
R3, R4, R9, R10, R18, R19, R20, R23, R28, R33, R34, R35, R36: 10k; R_0603_1608Metric
R5, R6: 30k; R_0603_1608Metric
R7: 20k; R_0603_1608Metric
R8, R11: 360k; R_0603_1608Metric
R12: 270k; R_0603_1608Metric
R13: 75k; R_0603_1608Metric
R14: 20m; R_2512_6332Metric
R15, R16, R21, R22, R24: 33; R_0603_1608Metric
R17, R27: 120k; R_0603_1608Metric
R25, R26: 3.3; R_0603_1608Metric
R29, R30, R31, R32: 1k; R_0603_1608Metric
SW1, SW2, SW3, SW4: SW_Omron_B3FS; SW_SPST_CK_RS282G05A3
U1: LP5907MFX-3.3; SOT-23-5
U2, U3: LM5164DDA; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias
U4: INA240A1PW; TSSOP-8_4.4x3mm_P0.65mm
U5: UCC27201A; SOIC-8_3.9x4.9mm_P1.27mm
U6: OPA2333xxD; SOIC-8_3.9x4.9mm_P1.27mm
U7: STM32F334C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: CSTCE12M; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C11.1, C14.1, C24.1, C28.1, C41.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, D8.2 (A), D9.2 (A), D13.2 (A), J1.1, J2.3, R28.1, R29.2, R30.2, R31.2, R32.2, R33.1, R34.1, R35.2, U1.5 (OUT), U4.5 (V+), U4.6 (REF2), U6.8 (V+), U7.1 (VBAT), U7.9 (VDDA), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD)
+5V: C3.1, C7.1, C18.2, C20.1, C22.1, D6.1 (A1), L1.2, R4.1, R13.2, U1.1 (IN), U1.3 (EN)
+12V: C19.2, C21.1, C23.1, C30.2, D7.1 (A1), L2.2, R3.1, R12.2, U5.1 (VDD)
CLK: J1.3, U7.37 (PA14)
DIO: J1.2, U7.34 (PA13)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.1, C31.2, C32.2, C33.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.1, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, D1.2 (A), D2.1 (K), D3.1 (K), D5.2 (A2), D6.2 (A2), D7.2 (A2), D8.1 (K), D9.1 (K), D12.2 (A), D13.1 (K), D17.1 (K), H2.1, H4.1, J1.4, J2.4, Q2.3 (S), R1.2, R2.2, R5.2, R6.2, R10.2, R18.1, R19.2, R20.2, R23.2, R36.1, SW1.2, SW2.2, SW3.2, SW4.2, U1.2 (GND), U2.1 (GND), U2.9 (EP), U3.1 (GND), U3.9 (EP), U4.1 (GND), U4.4 (GND), U4.7 (REF1), U5.7 (VSS)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
HI: R15.2, U7.29 (PA8)
HO: D4.1 (A1), D11.2 (A), Q1.1 (G), R9.1, R26.1
I+: L3.2, R14.1, U4.2 (+)
I-: C27.1, C29.1, C31.1, C33.1, C35.1, D12.1 (K), H3.1, R14.2, R27.2, U4.3 (-)
IS: C32.1, D9.3 (K), R22.1, U7.12 (PA2)
LI: R16.2, U7.30 (PA9)
LO: D5.1 (A1), D10.2 (A), Q2.1 (G), R10.1, R25.1
unnamed: C16.2, C18.1, R8.1
unnamed: C17.2, C19.1, R11.1
unnamed: D2.2 (A), R3.2, U2.6 (PGOOD)
unnamed: D3.2 (A), R4.2, U3.6 (PGOOD)
unnamed: D10.1 (K), R25.2, U5.8 (LO)
unnamed: D11.1 (K), R26.2, U5.3 (HO)
unnamed: D14.2 (A), R29.1
unnamed: D15.2 (A), R30.1
unnamed: D16.2 (A), R31.1
unnamed: D17.2 (A), R32.1
unnamed: R7.2, R13.1
unnamed: R22.2, U4.8
unnamed: C15.1, U2.7 (BST)
unnamed: C17.1, R6.1, R12.1, U2.5 (FB)
unnamed: R1.1, U2.4 (RON)
unnamed: C15.2, L2.1, R11.2, U2.8 (SW)
unnamed: C13.1, U3.7 (BST)
unnamed: C16.1, R5.1, R7.1, U3.5 (FB)
unnamed: R2.1, U3.4 (RON)
unnamed: C13.2, L1.1, R8.2, U3.8 (SW)
unnamed: C34.1, U5.2 (HB)
unnamed: R15.1, R18.2, U5.5 (HI)
unnamed: R16.1, R19.1, U5.6 (LI)
unnamed: C25.1, R17.1, R20.1, U6.3 (+)
unnamed: R24.2, U6.1, U6.2 (-)
unnamed: C37.1, R23.1, R27.1, U6.5 (+)
unnamed: R21.2, U6.6 (-), U6.7
unnamed: R36.2, U7.44 (BOOT0)
unnamed: U7.5 (PF0), Y1.1
unnamed: U7.6 (PF1), Y1.3
PB5: C39.1, R33.2, SW2.1, U7.41 (PB5)
PB6: C40.1, R34.2, SW3.1, U7.42 (PB6)
PB7: C38.1, R28.2, SW1.1, U7.43 (PB7)
PB13: D14.1 (K), U7.26 (PB13)
PB14: D15.1 (K), U7.27 (PB14)
PB15: D16.1 (K), U7.28 (PB15)
RS: C42.2, R35.1, SW4.1, U7.7 (NRST)
SCL: J2.2, U7.46 (PB9)
SDA: J2.1, U7.45 (PB8)
SW: C34.2, D4.2 (A2), L3.1, Q1.3 (S), Q2.2 (D), R9.2, U5.4 (HS)
VHS: C36.1, D13.3 (K), R24.1, U7.10 (PA0)
VIN: C1.1, C2.1, C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C12.1, D1.1 (K), H1.1, Q1.2 (D), R17.2, U2.2 (VIN), U2.3 (EN/UVLO), U3.2 (VIN), U3.3 (EN/UVLO)
VLS: C26.1, D8.3 (K), R21.1, U7.11 (PA1)

Notes on the sheet:
MOS驱动
2015电赛A题DC-DC变换器
电压电流采样
辅助电源
DC-DC主回路

Board: 4 copper layers, 58.0 x 59.2 mm, 124 parts (51 on the bottom side), 56 nets.

## Code that names these connections

File dcdc/dcdc.ioc (part):

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Mcu.Name=STM32F334C(4-6-8)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F334C8Tx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA8.Mode=Output_TA1TA2
PA8.Signal=HRTIM1_CHA1
PA9.Mode=Output_TA1TA2
PA9.Signal=HRTIM1_CHA2
PB13.GPIOParameters=PinState
PB13.PinState=GPIO_PIN_SET
PB13.Signal=GPIO_Output
PB14.GPIOParameters=PinState
PB14.PinState=GPIO_PIN_SET
PB14.Signal=GPIO_Output
PB15.GPIOParameters=PinState
PB15.PinState=GPIO_PIN_SET
PB15.Signal=GPIO_Output
PB6.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PB6.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB6.GPIO_PuPd=GPIO_PULLUP
PB6.Signal=GPXTI6
PB7.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PB7.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB7.GPIO_PuPd=GPIO_PULLUP
PB7.Signal=GPXTI7
PB8.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_ModeDefaultOutputPP
PB8.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB8.GPIO_PuPd=GPIO_PULLUP
PB8.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB8.PinState=GPIO_PIN_SET
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_ModeDefaultOutputPP
PB9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB9.GPIO_PuPd=GPIO_PULLUP
PB9.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB9.PinState=GPIO_PIN_SET
PB9.Signal=GPIO_Output
PF0\ /\ OSC_IN.Mode=HSE-External-Oscillator
PF0\ /\ OSC_IN.Signal=RCC_OSC_IN
PF1\ /\ OSC_OUT.Mode=HSE-External-Oscillator
PF1\ /\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSEPLLFreq_Value=12000000
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2025-06-07 init
2025-06-07 test
2025-06-07 add_code
2025-06-22 同步代码部分
2025-06-22 migrate
2025-07-16 sync
2025-07-19 添加adc和时钟
2025-07-22 添加oled和主控制
